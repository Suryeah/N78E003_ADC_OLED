# Keil uVision project I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include
  group Code
    ./: main.c
  group Common
    ./Common/: Common.c Delay.c
    ./: oled_i2c.c
  group Start Up
    ./Startup/: STARTUP.A51
